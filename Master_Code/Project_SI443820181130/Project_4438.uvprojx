# Keil uVision project Project_4438.uvprojx, settings and files
target SI4438 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project_4438 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source_Files\app\inc;.\Source_Files\drv_mcu\inc;.\Source_Files\drv_periph\inc;.\Source_Files\std_lib\inc;.\Source_Files\std_lib\startup;..\Project_SI443820181130
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ./Source_Files/app/src/: main.c
  group drv_periph
    ./Source_Files/drv_periph/src/: drv_SI4438.c
  group drv_mcu
    ./Source_Files/drv_mcu/src/: drv_button.c drv_delay.c drv_led.c drv_spi.c drv_uart.c
  group std_lib
    ./Source_Files/std_lib/src/: core_cm3.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c system_stm32f10x.c misc.c stm32f10x_exti.c
    ./Source_Files/std_lib/startup/: startup_stm32f10x_hd.s
