# Keil uVision project Greetea.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Greetea +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CodeChainer_20181207;.\CMSIS;.\driver;.\FWlib\inc;.\FWlib\src;.\driver\si44xx;.\driver\beep
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startcode
    ./CMSIS/Startup/arm/: startup_stm32f10x_hd.s
  group User
    ./: main.c stm32f10x_it.c readme.txt
  group Fwlib
    ./FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./CMSIS/: system_stm32f10x.c core_cm3.c
  group driver
    ./driver/: delay.c sys.c systick.c Usart.c timer2.c user_lib.c gprs.c Data_Bus.c led.c spi.c w25q64.c adc.c
    ./driver/si44xx/: drv_spi.c drv_SI4438.c
    ./driver/beep/: beep.c
software components: CMSIS:CORE 5.0.0
